# Keil uVision project ACI-Example.uvprojx, settings and files
target AN552_ACI (6240000::V6.24::.\ArmCompilerforEmbedded6.24)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.5.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x00000000,0x00080000) IROM(0x10000000,0x00200000) XRAM(0x01000000,0x00100000) XRAM2(0x20000000,0x00020000) XRAM3(0x20020000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: ACI-Example
  c flags: Optim=8 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: __USE_AN547__,___ARM_2D_CFG_SKIP_HEADER___
  c misc: -mcpu=cortex-m55+cdecp0
  c include: ..\platform;..\platform\mps3;..\platform\mps3\v2m_mps3;..\..\inc
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT6: RAM 0x1000000 size 0x100000
  memory RVCT7: RAM 0x20000000 size 0x20000
  memory RVCT8: RAM 0x20020000 size 0x20000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x80000
  scatter file: .\fvp_sse300_mps3_s.sct
  group platform
    ../platform/: app_platform.c Board_GLCD.h platform.h
    ../platform/mps3/: GLCD_V2M-MPS3_AN540.c platform_mps3.c stdout_USART.c
  group application
    ../: main.c cmsis_logo.c copy_with_mask_in_c.c
  group aci
    ../../inc/: aci_mve_lib.h
    ../../src/: aci_mve_lib.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS-View:Event Recorder 1.6.0, CMSIS-View:Fault:Record 1.1.0, CMSIS-View:Fault:Storage 1.1.0, CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2, Device:Startup 2.0.0, Utilities:perf_counter:Core 2.4.0, Utilities:perf_counter:Porting 1.1.1
